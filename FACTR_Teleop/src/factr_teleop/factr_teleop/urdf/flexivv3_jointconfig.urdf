Commit message: gravity comp working

File: FACTR_Teleop/src/factr_teleop/factr_teleop/urdf/flexivv3_jointconfig.urdf (robot description, URDF)
Before this commit: robot flexivv3_jointconfig, 19 links, 18 joints
Joints:
- joint revolute_5: axis 0 0 -1 -> 0 0 1
